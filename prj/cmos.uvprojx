# Keil uVision project cmos.uvprojx, settings and files
target cmos (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cmos
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: EMPL_TARGET_STM32F4,MPU9250,EMPL_TARGET_STM32F4
  c include: ..\cmos;..\cmos\lib;..\cmos\console;E:\Keil_v5\STM32Cube_FW_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;E:\Keil_v5\STM32Cube_FW_F4\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group st
    E:/Keil_v5/STM32Cube_FW_F4/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    E:/Keil_v5/STM32Cube_FW_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c
  group app
    ../app/flyer/: main.c
    ../app/flyer/mpu9250/: mpu9250.c
  group asm
    ../cmos/asm/starup/: stm32f429xx.s
  group hal
    ../cmos/hal/: stm32f4xx_hal_msp.c hal.c cortex.c
    ../cmos/hal/uart/: uart.c
    ../cmos/hal/i2c/: i2c.c
  group console
    ../cmos/console/: console.c
  group api
    ../cmos/api/: api.c
  group lib
    ../cmos/lib/: lib_assert.c
  group inv
    ../app/flyer/eMD6.12/core/driver/eMPL/: inv_mpu.c
