# Keil uVision project md.uvprojx, settings and files
target md (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: md +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: EMPL_TARGET_STM32F4,MPU9250,MPL_LOG_NDEBUG=1,EMPL,USE_DMP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../../../../cmos/asm/starup/: stm32f429xx.s
    ../User/src/: mpu9250_main.c
  group st
    ../STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_exti.c stm32f4xx_i2c.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c misc.c stm32f4xx_syscfg.c stm32f4xx_pwr.c
  group mpu
    ../core/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../core/driver/stm32L/: log_stm32.c
    ../core/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../: libmpllib.lib
    ../core/eMPL-hal/: eMPL_outputs.c
    ../Peripheral/src/: gpio.c i2c.c uart.c
  group bsp
    ../DeviceSupport/src/: system_stm32f4xx.c board-st_discovery.c
